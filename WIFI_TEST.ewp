# IAR project WIFI_TEST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: driverlib; inc; oslib; $PROJ_DIR$; common; simplelink; simplelink\source; simplelink\include; third_party\FreeRTOS\source; third_party\FreeRTOS\source\include; third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WIFI_TEST.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: simplelink\ewarm\OS\Exe\simplelink.a; driverlib\ewarm\Release\Exe\driverlib.a; oslib\ewarm\free_rtos\Exe\free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    common/: gpio_if.c startup_ewarm.c uart_if.c
    ./: main.c pinmux.c smartconfig.c spi_module.h
